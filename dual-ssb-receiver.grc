options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: ft8_freq_20m
  id: variable
  parameters:
    value: '14074000'
  states: {}
- name: ft8_freq_40m
  id: variable
  parameters:
    value: '7074000'
  states: {}
- name: rtl_freq_20m
  id: variable
  parameters:
    value: '14100000'
  states: {}
- name: rtl_freq_40m
  id: variable
  parameters:
    value: '7100000'
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: wspr_freq_20m
  id: variable
  parameters:
    value: '14095600'
  states: {}
- name: wspr_freq_40m
  id: variable
  parameters:
    value: '7038600'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: gr_20m_wspr
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: gr_20m_ft8
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    device_name: gr_40m_ft8
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: gr_40m_wspr
    samp_rate: audio_samp_rate
  states: {}
- name: dual_demodulator_20m
  id: dual_demodulator
  parameters:
    ft8_dial_freq: ft8_freq_20m
    rtl_freq: rtl_freq_20m
    wspr_dial_freq: wspr_freq_20m
  states: {}
- name: dual_demodulator_40m
  id: dual_demodulator
  parameters:
    ft8_dial_freq: ft8_freq_40m
    rtl_freq: rtl_freq_40m
    wspr_dial_freq: wspr_freq_40m
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: 20m FT8
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: 40m FT8
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: 40m WSPR
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: 20m WSPR
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_20m
  id: rtlsdr_source
  parameters:
    args: rtl=1,direct_samp=2
    bb_gain0: '20'
    freq0: rtl_freq_20m
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_40m
  id: rtlsdr_source
  parameters:
    args: rtl=0,direct_samp=2
    bb_gain0: '20'
    freq0: rtl_freq_40m
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [dual_demodulator_20m, '0', audio_sink_0_0_0, '0']
- [dual_demodulator_20m, '0', qtgui_waterfall_sink_x_0, '0']
- [dual_demodulator_20m, '1', audio_sink_0_0, '0']
- [dual_demodulator_20m, '1', qtgui_waterfall_sink_x_0_1, '0']
- [dual_demodulator_40m, '0', audio_sink_0_0_0_0, '0']
- [dual_demodulator_40m, '0', qtgui_waterfall_sink_x_0_0, '0']
- [dual_demodulator_40m, '1', audio_sink_0_0_1, '0']
- [dual_demodulator_40m, '1', qtgui_waterfall_sink_x_0_0_0, '0']
- [rtlsdr_source_20m, '0', dual_demodulator_20m, '0']
- [rtlsdr_source_40m, '0', dual_demodulator_40m, '0']

metadata:
  file_format: 1
