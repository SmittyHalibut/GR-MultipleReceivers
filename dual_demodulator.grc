options:
  parameters:
    category: '[SSB Receiver]'
    generate_options: hb
    id: dual_demodulator
    output_language: python
    title: Dual Demodulator
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_interp
  id: variable
  parameters:
    value: '2'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(rtl_samp_rate/decimation)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '30'
  states: {}
- name: filter_shoulder
  id: variable
  parameters:
    value: '400'
  states: {}
- name: ft8_audio_bw
  id: variable
  parameters:
    value: ft8_audio_high-ft8_audio_low
  states: {}
- name: ft8_audio_center
  id: variable
  parameters:
    value: int((ft8_audio_high-ft8_audio_low)/2+ft8_audio_low)
  states: {}
- name: ft8_audio_high
  id: variable
  parameters:
    value: 3000+(filter_shoulder/2)
  states: {}
- name: ft8_audio_low
  id: variable
  parameters:
    value: 300-(filter_shoulder/2)
  states: {}
- name: ft8_center_freq
  id: variable
  parameters:
    value: ft8_dial_freq-rtl_freq+(ft8_audio_center*ft8_usb_lsb)
  states: {}
- name: ft8_usb_lsb
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: wspr_audio_bw
  id: variable
  parameters:
    value: wspr_audio_high-wspr_audio_low
  states: {}
- name: wspr_audio_center
  id: variable
  parameters:
    value: int((wspr_audio_high-wspr_audio_low)/2+wspr_audio_low)
  states: {}
- name: wspr_audio_high
  id: variable
  parameters:
    value: 1600+(filter_shoulder/2)
  states: {}
- name: wspr_audio_low
  id: variable
  parameters:
    value: 1400-(filter_shoulder/2)
  states: {}
- name: wspr_center_freq
  id: variable
  parameters:
    value: wspr_dial_freq-rtl_freq+(wspr_audio_center*wspr_usb_lsb)
  states: {}
- name: wspr_usb_lsb
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_center_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: firdes.complex_band_pass(1, rtl_samp_rate, -ft8_audio_bw/2, ft8_audio_bw/2, filter_shoulder)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: wspr_center_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: firdes.complex_band_pass(1, rtl_samp_rate, -wspr_audio_bw/2, wspr_audio_bw/2, filter_shoulder)
    type: ccc
  states: {}
- name: ft8_dial_freq
  id: parameter
  parameters:
    label: FT8 Dial Frequency
    type: intx
    value: '7074000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ft8
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: wspr
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: RTL in
    type: complex
  states: {}
- name: rtl_freq
  id: parameter
  parameters:
    label: RTL center frequency
    type: intx
    value: '7100000'
  states: {}
- name: ssb_demodulator_0
  id: ssb_demodulator
  parameters:
    center_freq: ft8_audio_center
    local_samp_rate: audio_samp_rate
    usb_lsb: '1'
  states: {}
- name: ssb_demodulator_1
  id: ssb_demodulator
  parameters:
    center_freq: wspr_audio_center
    local_samp_rate: audio_samp_rate
    usb_lsb: '1'
  states: {}
- name: wspr_dial_freq
  id: parameter
  parameters:
    label: WSPR Dial Frequency
    type: intx
    value: '7038600'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ssb_demodulator_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', ssb_demodulator_1, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [ssb_demodulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [ssb_demodulator_1, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
